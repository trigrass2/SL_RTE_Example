# Keil uVision project F030Pro.uvprojx, settings and files
target F030 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: F030Pro +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c include: ..\Main;..\Boot;..\STM32F0xx_StdPeriph_Driver\inc;..\RTE_BSP;..\RTE_Config;..\RTE_Core;..\RTE_Port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Main
    ../Main/: main.c stm32f0xx_it.c
  group StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_flash.c stm32f0xx_wwdg.c
  group Boot
    ../Boot/: system_stm32f0xx.c startup_stm32f030.s
  group RTE_Core
    ../RTE_Core/: RTE_KVDB.c RTE_LinkList.c RTE_Math.c RTE_Memory.c RTE_Printf.c RTE_RoundRobin.c RTE_Shell.c RTE_StateMachine.c RTE_Stream.c RTE_Vector.c
  group RTE_Port
    ../RTE_Port/: RTE_Port.c
  group RTE_BSP
    ../RTE_BSP/: BSP_Com.c BSP_Led.c BSP_Systick.c BSP_Flash.c BSP_SoftPWM.c BSP_Key.c
software components: CMSIS:CORE 5.2.0
